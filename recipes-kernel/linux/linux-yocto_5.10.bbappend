FILESEXTRAPATHS:prepend:beaglebone-yocto := "${THISDIR}:"
SRC_URI += "file://defconfig"
