DESCRIPTION = "File is a utility that provides information about file types."
SECTION = "tools"

LICENSE = "BSD"

SRC_URI = "http://ftp.astron.com/pub/file/file-${PV}.tar.gz"

inherit autotools
